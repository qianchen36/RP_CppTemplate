# Keil uVision project RP_CppTemplate.uvprojx, settings and files
target RP_CppTemplate (6180000::V6.18::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RP_CppTemplate
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: .eide\deps;Applications\Config\Inc;Applications\Algo\Inc;Applications\Algo\Filter\Inc;Applications\Algo\Controller\Inc;Applications\Comm\Inc;Applications\Device\Inc;Applications\Device\RC\Inc;Applications\Device\Motor\Inc;Applications\Device\IMU\Inc;Applications\Module\Inc;Applications\System\Inc;Applications\System\Notify\Inc;Applications\System\Task\Inc;Boards\Dbldeck_MasterCtrl\Core\Inc;Boards\Dbldeck_MasterCtrl\BSP\Inc;Boards\Dbldeck_MasterCtrl\FATFS\Target;Boards\Dbldeck_MasterCtrl\FATFS\App;Boards\Dbldeck_MasterCtrl\USB_DEVICE\App;Boards\Dbldeck_MasterCtrl\USB_DEVICE\Target;Drivers\CMSIS\Include;Drivers\CMSIS\Device\ST\STM32F4xx\Include;Drivers\STM32F4xx_HAL_Driver\Inc;Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;Drivers\BMI270-Sensor-API;Middlewares\FatFs\src;Middlewares\FreeRTOS\Source\include;Middlewares\FreeRTOS\Source\portable\GCC\ARM_CM4F;Middlewares\STM32_USB_Device_Library\Core\Inc;Middlewares\STM32_USB_Device_Library\Class\CDC\Inc;Middlewares\CMSIS_DSP\Include;Middlewares\CMSIS_DSP\PrivateInclude
  asm define: USE_HAL_DRIVER,STM32F407xx
  memory RVCT1: ROM 0x08000000 size 0x00080000
  memory RVCT6: RAM 0x20000000 size 0x00020000
  memory RVCT7: RAM 0x10000000 size 0x00010000
  group Middlewares/USB_Device_Library
    Middlewares/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    Middlewares/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/FreeRTOS
    Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    Middlewares/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/FatFs
    Middlewares/FatFs/src/: diskio.c ff_gen_drv.c ff.c
    Middlewares/FatFs/src/option/: ccsbcs.c syscall.c
  group Middlewares/CMSIS_DSP
    Middlewares/CMSIS_DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
    Middlewares/CMSIS_DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
    Middlewares/CMSIS_DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
    Middlewares/CMSIS_DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
    Middlewares/CMSIS_DSP/Source/ControllerFunctions/: ControllerFunctions.c
    Middlewares/CMSIS_DSP/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
    Middlewares/CMSIS_DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
    Middlewares/CMSIS_DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
    Middlewares/CMSIS_DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
    Middlewares/CMSIS_DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
    Middlewares/CMSIS_DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    Middlewares/CMSIS_DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
    Middlewares/CMSIS_DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
    Middlewares/CMSIS_DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
    Middlewares/CMSIS_DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
    Middlewares/CMSIS_DSP/Source/WindowFunctions/: WindowFunctions.c
  group Drivers/STM32F4xx_HAL_Driver
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rng.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_ll_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    Boards/Dbldeck_MasterCtrl/Core/Src/: system_stm32f4xx.c
  group Drivers/BMI270-Sensor-API
    Drivers/BMI270-Sensor-API/: bmi2.c bmi270.c
  group Board/Dbldeck_MasterCtrl/USB_DEVICE/Target
    Boards/Dbldeck_MasterCtrl/USB_DEVICE/Target/: usbd_conf.c
  group Board/Dbldeck_MasterCtrl/USB_DEVICE/App
    Boards/Dbldeck_MasterCtrl/USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Board/Dbldeck_MasterCtrl/MDK-ARM
    Boards/Dbldeck_MasterCtrl/MDK-ARM/: armlib_lock_glue.c startup_stm32f407xx.s
  group Board/Dbldeck_MasterCtrl/FATFS/Target
    Boards/Dbldeck_MasterCtrl/FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Board/Dbldeck_MasterCtrl/FATFS/App
    Boards/Dbldeck_MasterCtrl/FATFS/App/: fatfs.c
  group Board/Dbldeck_MasterCtrl/Core
    Boards/Dbldeck_MasterCtrl/Core/Src/: adc.c can.c crc.c dma.c gpio.c i2c.c iwdg.c main.c rng.c sdio.c spi.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c tim.c usart.c
  group Board/Dbldeck_MasterCtrl/BSP
    Boards/Dbldeck_MasterCtrl/BSP/: board.cpp FreeRTOS_port.c
  group Application/System
    Applications/System/: system.cpp
  group Application/System/Task
    Applications/System/Task/: heartbeat_task.cpp monitor_task.cpp task.cpp
  group Application/System/Notify
    Applications/System/Notify/: notify.cpp
  group Application/Module
    Applications/Module/: mod_chassis.cpp module.cpp
  group Application/Device
    Applications/Device/: device.cpp
  group Application/Device/RC
    Applications/Device/RC/: rc_dr16.cpp rc.cpp
  group Application/Device/Motor
    Applications/Device/Motor/: motor.cpp mtr_gm6020.cpp mtr_m2006.cpp mtr_m3508.cpp
  group Application/Device/IMU
    Applications/Device/IMU/: imu_bmi270.cpp imu.cpp
  group Application/Config
    Applications/Config/: config_comm.cpp config_device.cpp config_module.cpp config_system.cpp config.cpp
  group Application/Comm
    Applications/Comm/: comm_can.cpp comm_spi.cpp comm_uart.cpp comm.cpp
  group Application/Algo
    Applications/Algo/: algo.cpp
  group Application/Algo/Filter
    Applications/Algo/Filter/: filter.cpp fl_ave.cpp
  group Application/Algo/Controller
    Applications/Algo/Controller/: controller.cpp ctrl_pid.cpp
